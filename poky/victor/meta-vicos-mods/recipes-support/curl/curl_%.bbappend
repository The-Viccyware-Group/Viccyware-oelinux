PACKAGECONFIG:append:pn-curl = " nghttp2"
DEPENDS:append:pn-curl = " nghttp2"
