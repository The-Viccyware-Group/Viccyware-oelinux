RDEPENDS:${PN}-scripts = "${PN} \
                          bash \
                          util-linux-lsblk \
                          util-linux-findmnt"